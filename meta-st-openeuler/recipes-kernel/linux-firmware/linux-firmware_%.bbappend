
OPENEULER_REPO_NAMES += " nvram-murata murata"

SRC_URI:append = " \
        file://murata \
        file://nvram-murata \
    "
