# ACM supports
IMAGE_INSTALL += " \
    acm-yang-module \
    acm-demo \
    monitoring-client \
"
# kernel addons
IMAGE_INSTALL += " \
    kernel-module-tsn-acm \
"
