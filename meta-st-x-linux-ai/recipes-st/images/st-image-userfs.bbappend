PACKAGE_INSTALL += "\
    packagegroup-x-linux-ai-demo \
"
