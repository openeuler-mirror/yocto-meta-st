# add vendorfs packages to support NPU
PACKAGE_INSTALL:append:stm32mp25common = " libopenvx-gcnano libovxkernels-gcnano "
