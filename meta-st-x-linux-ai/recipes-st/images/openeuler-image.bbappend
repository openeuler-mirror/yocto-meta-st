IMAGE_INSTALL += " \
        packagegroup-x-linux-ai-demo \
   "
